# Keil uVision project Controller.uvprojx, settings and files
target Controller (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Controller +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\STARTUP;.\FWLIB\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\BASIC\delay;.\BASIC\spi;.\BASIC\sys;.\BASIC\usart;.\BASIC\i2c;.\USER;.\HARDWARE\JOY_STICK;.\HARDWARE\LED;.\HARDWARE\NRF24L01;.\HARDWARE\OLED096;.\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./STARTUP/: startup_stm32f10x_md.s
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group BASIC
    ./BASIC/delay/: delay.c
    ./BASIC/spi/: spi.c
    ./BASIC/sys/: sys.c
    ./BASIC/usart/: usart.c
    ./BASIC/i2c/: i2c.c
  group HARDWARE
    ./HARDWARE/JOY_STICK/: joy_stick.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/NRF24L01/: 24l01.c
    ./HARDWARE/OLED096/: oled096.c
    ./HARDWARE/TIMER/: timer.c
  group USER
    ./USER/: main.c stm32f10x_it.c
